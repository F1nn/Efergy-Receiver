options:
  parameters:
    author: James Finniss
    description: Receiver for the Efergy Engage wireless power meter. FSK on 433.5MHz
    generate_options: no_gui
    id: engage_receiver
    output_language: python
    run_options: run
    title: Engage Sensor Receiver
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 433.53e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1.0'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1.0'
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '500'
    max_iter: '4096'
    scale: 1.0/500
    type: float
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """GNU Radio Embedded Python Block: Efergy E2CT decoder with adaptive detection.

      Input 0: uint8 FSK binary slicer output (0/1)
      Input 1: float32 averaged complex-IQ power, same sample rate
      Input 2: float32 quadrature demodulator output (after float lowpass), same sample rate
      Output: 'packet' PMT dictionary

      Optimization: vectorized monitoring and bulk processing of noise-only spans.
      Captures still use the original sample-by-sample detector and packet decoder.
      """
      import math
      import os
      import time
      from collections import deque

      import numpy as np
      import pmt
      from gnuradio import gr

      # Logging settings: edit here; no new GRC constructor properties required.
      # normal: one PKT line for each valid packet + summary every 5 minutes.
      # debug: also show 10-second RF monitor and rejection details.
      # quiet: print only warnings/gaps, no routine packet or summary logs.
      LOG_LEVEL = "normal"  # "quiet", "normal", "debug"
      SUMMARY_INTERVAL = 300.0  # seconds; 0 disables periodic summaries


      class blk(gr.sync_block):
          def __init__(self, sample_rate=500000, detection_mode="adaptive",
                       detection_snr_db=10.0, release_snr_db=6.0,
                       noise_time_constant=1.0, min_detection_us=100.0,
                       threshold_on=0.01, threshold_off=0.003,
                       initial_noise_power=0.00012, center_freq=433.53e6, debug=False):
              gr.sync_block.__init__(
                  self, name="Engage E2CT Decoder",
                  in_sig=[np.uint8, np.float32, np.float32], out_sig=[])
              self.fs = float(sample_rate)
              self.center_freq = float(center_freq)
              if not math.isfinite(self.center_freq):
                  raise ValueError("center_freq must be finite")
              self.mode = str(detection_mode).lower()
              self.on = float(threshold_on)
              self.off = float(threshold_off)
              self.debug = bool(debug)
              self.noise = float(initial_noise_power)
              self.ratio_on = 10 ** (float(detection_snr_db) / 10)
              self.ratio_off = 10 ** (float(release_snr_db) / 10)
              if self.fs <= 0 or self.mode not in ("adaptive", "manual"):
                  raise ValueError("sample_rate must be positive; detection_mode must be adaptive or manual")
              if self.mode == "manual" and not 0 <= self.off < self.on:
                  raise ValueError("manual threshold_off must be below threshold_on")
              if self.mode == "adaptive" and not self.ratio_on > self.ratio_off > 1:
                  raise ValueError("adaptive detection_snr_db must exceed release_snr_db, both > 0")
              if self.noise <= 0 or noise_time_constant <= 0:
                  raise ValueError("initial_noise_power and noise_time_constant must be positive")

              self.alpha = -math.expm1(-1.0 / (self.fs * float(noise_time_constant)))
              self.decay = 1.0 - self.alpha
              self.detect_samples = max(1, round(float(min_detection_us) * 1e-6 * self.fs))
              self.pre_samples = max(1, round(0.003 * self.fs))
              self.end_samples = max(1, round(0.002 * self.fs))
              self.max_samples = max(1, round(0.080 * self.fs))
              self.history = deque(maxlen=self.pre_samples)
              self.power_history = deque(maxlen=self.pre_samples)
              self.freq_history = deque(maxlen=self.pre_samples)
              self.receiving = False
              self.candidate_count = 0
              self.low_count = 0
              self.data = []
              self.power_data = []
              self.freq_data = []
              self.capture_noise = self.noise
              self.capture_off_threshold = self.noise * self.ratio_off
              self.packet_count = 0
              self.reject_count = 0
              self.stats = {key: 0 for key in (
                  "captures", "valid", "too_short", "no_sync", "no_64_symbols",
                  "checksum_failed", "invalid_payload", "capture_timeout")}
              self.stats_interval = float(SUMMARY_INTERVAL)
              self.stats_last_print = time.monotonic()
              self.last_valid_time = {}  # per sensor, not global
              self.sensor_reception = {}  # id -> {received, missed}, since decoder start
              self.monitor_interval = 10.0
              self.monitor_started = time.monotonic()
              self.monitor_samples = 0
              self.monitor_peak = 0.0
              self.monitor_above = 0
              self.monitor_captures = 0
              self.monitor_valid = 0
              self.monitor_rejected = 0
              self.message_port_register_out(pmt.intern("packet"))
              # Optional GPIO LED: disabled unless ENGAGE_STATUS_LED_GPIO is set.
              self._status_led = None
              self._status_led_deadline = 0.0
              led_gpio = os.environ.get("ENGAGE_STATUS_LED_GPIO", "").strip()
              if led_gpio:
                  try:
                      import gpiod
                      from gpiod.line import Direction, Value

                      self._status_led_gpio = int(led_gpio)
                      self._status_led_value = Value
                      self._status_led = gpiod.request_lines(
                          os.environ.get("ENGAGE_STATUS_LED_CHIP", "/dev/gpiochip0"),
                          consumer="engage-status-led",
                          config={self._status_led_gpio: gpiod.LineSettings(
                              direction=Direction.OUTPUT,
                              output_value=Value.INACTIVE,
                          )},
                      )
                  except (ImportError, AttributeError, OSError, ValueError, RuntimeError) as exc:
                      print(f"STATUS LED unavailable: {exc}", flush=True)

          def _set_status_led(self, value):
              if self._status_led is None:
                  return
              try:
                  self._status_led.set_value(self._status_led_gpio, value)
              except (OSError, RuntimeError) as exc:
                  print(f"STATUS LED write failed: {exc}", flush=True)
                  try:
                      self._status_led.release()
                  except (OSError, RuntimeError):
                      pass
                  self._status_led = None

          def stop(self):
              if self._status_led is not None:
                  self._set_status_led(self._status_led_value.INACTIVE)
                  if self._status_led is not None:
                      self._status_led.release()
                      self._status_led = None
              return True

          def _thresholds(self):
              if self.mode == "manual":
                  return self.on, self.off
              return self.noise * self.ratio_on, self.noise * self.ratio_off

          def _quiet_span(self, bits, powers, frequencies):
              """Bulk-update idle samples while preserving EMA and pre-trigger history.

              This is only called when every power sample is safely below the
              entry threshold. The complete span is known to contain no trigger.
              """
              n = len(powers)
              if not n:
                  return
              # Equivalent to a per-sample EMA for constant or changing idle input:
              # y[n] = d**n*y[0] + alpha*sum(d**(n-1-k)*x[k]).
              # Chunk sizes stay modest, avoiding excessively large temp arrays.
              if self.mode in ("adaptive", "manual"):
                  weights = np.power(self.decay, np.arange(n - 1, -1, -1, dtype=np.float64))
                  self.noise = (self.decay ** n) * self.noise + self.alpha * float(
                      np.dot(weights, powers.astype(np.float64, copy=False)))
              self.history.extend(int(b) for b in bits[-self.pre_samples:])
              self.power_history.extend(float(p) for p in powers[-self.pre_samples:])
              self.freq_history.extend(float(f) for f in frequencies[-self.pre_samples:])
              self.candidate_count = 0

          def _process_sample(self, bit, level, frequency):
              """Original detector, used whenever a burst might be present."""
              bit = int(bit)
              level = float(level)
              frequency = float(frequency) if math.isfinite(float(frequency)) else 0.0
              if not math.isfinite(level) or level < 0:
                  level = 0.0
              on, off = self._thresholds()
              if not self.receiving:
                  self.history.append(bit)
                  self.power_history.append(level)
                  self.freq_history.append(frequency)
                  if level >= on:
                      self.candidate_count += 1
                      if self.candidate_count >= self.detect_samples:
                          self.receiving = True
                          self.data = list(self.history)
                          self.power_data = list(self.power_history)
                          self.freq_data = list(self.freq_history)
                          self.capture_noise = self.noise
                          self.capture_off_threshold = off
                          self.low_count = 0
                          self.candidate_count = 0
                      return
                  self.candidate_count = 0
                  self.noise += self.alpha * (level - self.noise)
                  return

              self.data.append(bit)
              self.power_data.append(level)
              self.freq_data.append(frequency)
              if level < off:
                  self.low_count += 1
              else:
                  self.low_count = 0
              if self.low_count >= self.end_samples or len(self.data) >= self.max_samples:
                  timed_out = len(self.data) >= self.max_samples
                  packet = np.asarray(self.data, dtype=np.uint8)
                  powers = np.asarray(self.power_data, dtype=np.float32)
                  frequencies = np.asarray(self.freq_data, dtype=np.float32)
                  self.receiving = False
                  self.data = []
                  self.power_data = []
                  self.freq_data = []
                  self.history.clear()
                  self.power_history.clear()
                  self.freq_history.clear()
                  self.stats["captures"] += 1
                  self.monitor_captures += 1
                  if timed_out:
                      self.stats["capture_timeout"] += 1
                  self._decode_capture(packet, powers, frequencies,
                                       self.capture_noise, self.capture_off_threshold)

          def work(self, input_items, output_items):
              # Clear the pulse from an earlier valid packet without blocking DSP.
              if self._status_led_deadline and time.monotonic() >= self._status_led_deadline:
                  self._set_status_led(self._status_led_value.INACTIVE)
                  self._status_led_deadline = 0.0
              digital, power, frequencies = input_items
              n = min(len(digital), len(power), len(frequencies))
              if n == 0:
                  return 0
              digital = digital[:n]
              power = power[:n]
              frequencies = frequencies[:n]
              # Vectorized monitoring (the previous version performed these operations
              # 500,000 times per second in the Python loop).
              finite = np.isfinite(power)
              clean_power = np.where(finite & (power >= 0), power, 0.0)
              self.monitor_samples += n
              self.monitor_peak = max(self.monitor_peak, float(np.max(clean_power)))
              self.monitor_above += int(np.count_nonzero(clean_power >= self._thresholds()[0]))

              # Keep the size small so the adaptive threshold cannot move much inside
              # a chunk. Guard against moving noise estimates by requiring all values
              # below a CONSERVATIVE lower bound on the threshold; otherwise use the
              # exact original per-sample path.
              CHUNK = 512
              for start in range(0, n, CHUNK):
                  end = min(start + CHUNK, n)
                  p = clean_power[start:end]
                  b = digital[start:end]
                  f = frequencies[start:end]
                  on, _ = self._thresholds()
                  if (not self.receiving and self.candidate_count == 0
                          and float(np.max(p)) < on * 0.75):
                      self._quiet_span(b, p, f)
                  else:
                      for bit, level, freq in zip(b, p, f):
                          self._process_sample(bit, level, freq)

              now = time.monotonic()
              if now - self.monitor_started >= self.monitor_interval:
                  elapsed = now - self.monitor_started
                  rate = self.monitor_samples / elapsed if elapsed > 0 else 0.0
                  on, off = self._thresholds()
                  if LOG_LEVEL == "debug":
                      print(
                          f"RF {elapsed:.0f}s processed={rate/1000:.1f} kS/s "
                          f"peak={self.monitor_peak:.4g} noise={self.noise:.3g} "
                          f"on={on:.3g} off={off:.3g} "
                          f"above_on={100 * self.monitor_above / max(1,self.monitor_samples):.3f}% "
                          f"state={'RECEIVING' if self.receiving else 'IDLE'} "
                          f"captures={self.monitor_captures} "
                          f"valid={self.monitor_valid} rejected={self.monitor_rejected}",
                          flush=True)
                  self.monitor_started = now
                  self.monitor_samples = 0
                  self.monitor_peak = 0.0
                  self.monitor_above = 0
                  self.monitor_captures = 0
                  self.monitor_valid = 0
                  self.monitor_rejected = 0
              if self.stats_interval > 0 and now - self.stats_last_print >= self.stats_interval:
                  if LOG_LEVEL != "quiet":
                      self._report_stats()
                  self.stats_last_print = now
              return n

          @staticmethod
          def _decode_payload(raw):
              if len(raw) != 8 or (raw[0] & 0xF0) != 0:
                  return None
              if sum(b == 0 for b in raw) > 5:
                  return None
              checksum_sum = sum(raw[:7])
              if checksum_sum == 0:
                  return None
              checksum_calc = checksum_sum & 0xFF
              checksum_rx = raw[7]
              if checksum_calc != checksum_rx:
                  return None
              exponent = 15 - raw[6]
              if not 7 <= exponent <= 23:
                  return None
              interval = (((raw[3] & 0x30) >> 4) + 1) * 6
              return {
                  "model": "Efergy-e2CT", "id": raw[1] | (raw[2] << 8),
                  "current": ((raw[4] << 8) | raw[5]) / float(1 << exponent),
                  "battery_ok": bool(raw[3] & 0x40), "interval": interval,
                  "learn": bool(raw[3] & 0x80), "mic": "CHECKSUM",
                  "checksum_received": checksum_rx, "checksum_calculated": checksum_calc,
                  "checksum_ok": True, "raw": raw.hex(),
              }

          @staticmethod
          def _rf_metrics(powers, noise_power, release_threshold):
              tiny = 1e-15
              noise_power = max(float(noise_power), tiny)
              active = powers[powers >= max(float(release_threshold), noise_power * 2)]
              if active.size == 0:
                  return None
              signal_power = max(float(np.median(active)), tiny)
              signal_excess = max(signal_power - noise_power, tiny)
              return {
                  "rssi": round(10 * math.log10(signal_power), 2),
                  "noise": round(10 * math.log10(noise_power), 2),
                  "snr": round(10 * math.log10(signal_excess / noise_power), 2),
                  "rf_power_unit": "dBFS",
              }

          def _frequency_metrics(self, samples, powers, demod, release_threshold):
              """Estimate the two FSK tone frequencies from stable pulse interiors.

              Quad Demod gain=1 output is radians/sample; scale by fs/(2*pi).
              Drop 12 us at each edge to avoid low-pass transition ringing.
              Mask samples without RF power to avoid noise-only frequency values.
              """
              if len(samples) != len(powers) or len(samples) != len(demod):
                  return {}
              edges = np.flatnonzero(np.diff(samples.astype(np.int16))) + 1
              starts = np.r_[0, edges]
              ends = np.r_[edges, len(samples)]
              guard = max(1, round(12e-6 * self.fs))
              threshold = max(float(release_threshold), 1e-12)
              tone_samples = [[], []]
              for start, end in zip(starts, ends):
                  if end - start < 2 * guard + 10:
                      continue
                  a, b = start + guard, end - guard
                  active = powers[a:b] >= threshold
                  if not np.any(active):
                      continue
                  values = demod[a:b][active]
                  values = values[np.isfinite(values)]
                  if values.size:
                      tone_samples[int(samples[start])].append(values)
              if not all(tone_samples):
                  return {}
              tones = [np.concatenate(parts) for parts in tone_samples]
              # Require a minimum number of stable samples for each tone.
              if min(len(t) for t in tones) < 30:
                  return {}
              hz = [float(np.median(t)) * self.fs / (2 * math.pi) for t in tones]
              low, high = sorted(hz)
              return {
                  "mod": "FSK",
                  "freq1": round((self.center_freq + high) / 1e6, 6),
                  "freq2": round((self.center_freq + low) / 1e6, 6),
                  "fsk_deviation_khz": round((high - low) / 2000.0, 3),
              }

          def _publish_packet(self, measurement):
              measurement["timestamp"] = time.time()
              now = time.monotonic()
              sensor_id = measurement["id"]
              previous = self.last_valid_time.get(sensor_id)
              if previous is not None:
                  gap = now - previous
                  expected = float(measurement["interval"])
                  if gap >= 1.5 * expected:
                      print(f"GAP id={sensor_id} {gap:.1f}s since previous valid packet "
                            f"(expected {expected:g}s)", flush=True)
              counters = self.sensor_reception.setdefault(sensor_id, {"received": 0, "missed": 0})
              if previous is not None:
                  # Infer missed intervals between valid packets. There is no RF
                  # sequence number, so this is an estimate, not a direct count.
                  expected_interval = float(measurement["interval"])
                  intervals = max(1, round((now - previous) / expected_interval))
                  counters["missed"] += max(0, intervals - 1)
              counters["received"] += 1
              total = counters["received"] + counters["missed"]
              measurement["packets_received"] = counters["received"]
              measurement["packets_missed_est"] = counters["missed"]
              measurement["reception_rate"] = round(100.0 * counters["received"] / total, 2)
              self.last_valid_time[sensor_id] = now
              self.packet_count += 1
              self.stats["valid"] += 1
              self.monitor_valid += 1
              measurement["packet_count"] = self.packet_count
              self.message_port_pub(pmt.intern("packet"), pmt.to_pmt(measurement))
              if self._status_led is not None:
                  self._set_status_led(self._status_led_value.ACTIVE)
                  self._status_led_deadline = time.monotonic() + 0.12
              rf = ""
              if "snr" in measurement:
                  rf = (f" rssi={measurement['rssi']:.2f} dBFS"
                        f" noise={measurement['noise']:.2f} dBFS"
                        f" snr={measurement['snr']:.2f} dB")
              freq_text = ""
              if "freq1" in measurement and "freq2" in measurement:
                  freq_text = (f" fsk={measurement['freq2']:.4f}/{measurement['freq1']:.4f}MHz"
                               f" dev={measurement['fsk_deviation_khz']:.1f}kHz")
              if LOG_LEVEL != "quiet":
                  print(
                      f"PKT id={sensor_id} current={measurement['current']:.3f}A "
                      f"interval={measurement['interval']}s "
                      f"snr={measurement.get('snr', float('nan')):.1f}dB "
                      f"rx={measurement['reception_rate']:.1f}% "
                      f"missed~{measurement['packets_missed_est']} "
                      f"checksum=OK",
                      flush=True)

          def _report_stats(self):
              s = self.stats
              rejected = s["captures"] - s["valid"]
              on, off = self._thresholds()
              print(
                  "STATS cumulative "
                  f"captures={s['captures']} valid={s['valid']} rejected={rejected} "
                  f"too_short={s['too_short']} no_sync={s['no_sync']} "
                  f"no_64_symbols={s['no_64_symbols']} "
                  f"checksum_failed={s['checksum_failed']} "
                  f"invalid_payload={s['invalid_payload']} "
                  f"capture_timeout={s['capture_timeout']} "
                  f"noise={self.noise:.6g} on={on:.6g} off={off:.6g}", flush=True)

          def _reject(self, reason, duration_ms, details=""):
              self.reject_count += 1
              self.stats[reason] += 1
              self.monitor_rejected += 1
              if self.debug or LOG_LEVEL == "debug":
                  print(f"REJECT {reason} duration={duration_ms:.2f}ms {details}", flush=True)

          def _decode_capture(self, samples, powers, demod, noise_power, release_threshold):
              duration_ms = len(samples) / self.fs * 1000
              if samples.size < round(0.005 * self.fs):
                  self._reject("too_short", duration_ms)
                  return
              edges = np.flatnonzero(np.diff(samples.astype(np.int16))) + 1
              starts = np.r_[0, edges]
              ends = np.r_[edges, samples.size]
              levels = samples[starts]
              lengths = ends - starts
              has_sync = False
              has_window = False
              has_checksum_failure = False
              polarities = []
              for polarity in (1, 0):
                  widths = lengths[levels == polarity] / self.fs * 1e6
                  sync_idx = np.flatnonzero((widths >= 300) & (widths <= 800))
                  has_sync |= bool(sync_idx.size)
                  symbols = []
                  for width in widths:
                      if 35 <= width < 100:
                          symbols.append(0)
                      elif 100 <= width <= 190:
                          symbols.append(1)
                      else:
                          symbols.append(None)
                  starts_to_try = sorted(set(
                      [int(i) + 1 for i in sync_idx]
                      + list(range(max(0, len(symbols) - 63)))
                  ))
                  polarities.append(f"{polarity}:{len(widths)}p/{len(sync_idx)}sync")
                  for start in starts_to_try:
                      chunk = symbols[start:start + 64]
                      if len(chunk) != 64 or any(bit is None for bit in chunk):
                          continue
                      has_window = True
                      for invert in (False, True):
                          bits = [bit ^ int(invert) for bit in chunk]
                          raw = bytes(
                              int("".join(str(b) for b in bits[i:i + 8]), 2)
                              for i in range(0, 64, 8)
                          )
                          if (raw[0] & 0xF0) == 0xF0:
                              raw = bytes(b ^ 0xFF for b in raw)
                          if (raw[0] & 0xF0) == 0 and sum(b == 0 for b in raw) <= 5:
                              if (sum(raw[:7]) & 0xFF) != raw[7]:
                                  has_checksum_failure = True
                          measurement = self._decode_payload(raw)
                          if measurement is not None:
                              metrics = self._rf_metrics(powers, noise_power, release_threshold)
                              if metrics is not None:
                                  measurement.update(metrics)
                              measurement.update(self._frequency_metrics(samples, powers, demod, release_threshold))
                              self._publish_packet(measurement)
                              return
              if not has_window:
                  reason = "no_64_symbols" if has_sync else "no_sync"
              elif has_checksum_failure:
                  reason = "checksum_failed"
              else:
                  reason = "invalid_payload"
              self._reject(reason, duration_ms,
                           f"polarity={','.join(polarities)} valid_64bit_window={has_window}")
    center_freq: freq
    debug: 'False'
    detection_mode: '"adaptive"'
    detection_snr_db: '10.0'
    initial_noise_power: '0.00012'
    min_detection_us: '100'
    noise_time_constant: '1.0'
    release_snr_db: '6.0'
    sample_rate: samp_rate / 2
    threshold_off: '0.003'
    threshold_on: '0.01'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """GNU Radio 3.10 Embedded Python Block: multi-sensor Efergy MQTT publisher.

      Input: PMT dictionary messages on port 'packet' from the existing decoder.
      RF availability times out 45 seconds after the last validated packet for each sensor.
      Requires paho-mqtt 2.x. No stream inputs or outputs.
      """
      import json
      import os
      import re
      import threading
      import time
      from datetime import datetime, timezone

      import pmt
      from gnuradio import gr
      import paho.mqtt.client as mqtt


      class blk(gr.basic_block):
          def __init__(self, mqtt_host="localhost", mqtt_port=1883,
                       mqtt_user="", mqtt_password="",
                       mqtt_topic="efergy/events", receiver_id=None,
                       sensor_topic_prefix="engage"):
              gr.basic_block.__init__(self, name="MQTT Multi-Sensor + RF Watchdog",
                                      in_sig=None, out_sig=None)
              self.mqtt_topic = str(mqtt_topic).strip().strip('/')
              self.prefix = str(sensor_topic_prefix).strip().strip('/')
              receiver_id = receiver_id or os.uname().nodename
              self.receiver_id = re.sub(r'[^a-zA-Z0-9_-]', '_', str(receiver_id)).strip('_')
              self.rf_timeout = 45.0  # seconds since last validated packet
              if not self.prefix or not self.receiver_id or not self.mqtt_topic:
                  raise ValueError("mqtt_topic, sensor_topic_prefix and receiver_id are required")

              # A receiver is a real MQTT client; each transmitter has independent RF status.
              self.receiver_topic = f"{self.prefix}/receivers/{self.receiver_id}/availability"
              self.sensors = {}  # sensor_id -> last_valid, interval, rf_online, last_packet
              self.connected = False
              self.lock = threading.RLock()
              self.stopping = threading.Event()

              self.message_port_register_in(pmt.intern("packet"))
              self.set_msg_handler(pmt.intern("packet"), self.handle_packet)

              client_id = f"gnuradio_{self.receiver_id}_{os.getpid()}"
              self.client = mqtt.Client(
                  callback_api_version=mqtt.CallbackAPIVersion.VERSION2,
                  client_id=client_id,
                  protocol=mqtt.MQTTv311,
              )
              if str(mqtt_user):
                  self.client.username_pw_set(str(mqtt_user), str(mqtt_password))
              self.client.will_set(self.receiver_topic, "offline", qos=1, retain=True)
              self.client.on_connect = self.on_connect
              self.client.on_message = self.on_message
              self.client.on_disconnect = self.on_disconnect
              self.client.on_connect_fail = self.on_connect_fail
              self.client.reconnect_delay_set(min_delay=1, max_delay=30)
              self.client.connect_async(str(mqtt_host), int(mqtt_port), keepalive=60)
              self.client.loop_start()

              self.watchdog = threading.Thread(target=self._watchdog_loop,
                                                name="engage-rf-watchdog", daemon=True)
              self.watchdog.start()
              print(f"MQTT starting client={client_id}", flush=True)

          def _base(self, sensor_id):
              # Sensor state is namespaced by receiver AND transmitter, avoiding
              # collisions if a second SDR hears the same sensor on another Pi.
              return f"{self.prefix}/receivers/{self.receiver_id}/sensors/{sensor_id}"

          def _rf_topic(self, sensor_id):
              return f"{self._base(sensor_id)}/rf_availability"

          def _state_topic(self, sensor_id):
              return f"{self._base(sensor_id)}/state"

          def _publish(self, topic, value, retain=False):
              try:
                  result = self.client.publish(topic, value, qos=1, retain=retain)
                  if result.rc != mqtt.MQTT_ERR_SUCCESS:
                      print(f"MQTT publish error on {topic}: "
                            f"{mqtt.error_string(result.rc)} ({result.rc})", flush=True)
                      return False
                  return True
              except Exception as exc:
                  print(f"MQTT publish exception on {topic}: {exc}", flush=True)
                  return False

          def _discovery(self, sensor_id):
              # Publish per transmitter only when first seen and after MQTT reconnect.
              device_key = f"engage_{self.receiver_id}_{sensor_id}"
              rf_topic = self._rf_topic(sensor_id)
              common = {
                  "state_topic": self._state_topic(sensor_id),
                  "availability_mode": "all",
                  "availability": [
                      {"topic": self.receiver_topic, "payload_available": "online",
                       "payload_not_available": "offline"},
                      {"topic": rf_topic, "payload_available": "online",
                       "payload_not_available": "offline"},
                  ],
                  "device": {
                      "identifiers": [device_key],
                      "name": f"Engage E2CT {sensor_id} ({self.receiver_id})",
                      "manufacturer": "Efergy", "model": "e2CT",
                  },
              }
              entities = (
                  ("sensor", "current", "Current", {
                      "value_template": "{{ value_json.current | round(3) }}",
                      "unit_of_measurement": "A", "device_class": "current",
                      "state_class": "measurement",
                  }),
                  ("binary_sensor", "battery_low", "Battery Low", {
                      "value_template": "{{ 'OFF' if value_json.battery_ok else 'ON' }}",
                      "device_class": "battery", "payload_on": "ON", "payload_off": "OFF",
                  }),
                  ("sensor", "last_received", "Last Received", {
                      "value_template": "{{ value_json.received_at }}",
                      "device_class": "timestamp", "entity_category": "diagnostic",
                  }),
                  ("sensor", "packet_count", "Packet Count", {
                      "value_template": "{{ value_json.sensor_packet_count }}",
                      "entity_category": "diagnostic", "icon": "mdi:counter",
                  }),
                  ("binary_sensor", "checksum_error", "Checksum Error", {
                      "value_template": "{{ 'OFF' if value_json.checksum_ok else 'ON' }}",
                      "device_class": "problem", "payload_on": "ON", "payload_off": "OFF",
                      "entity_category": "diagnostic",
                  }),
                  ("sensor", "rssi", "RSSI", {
                      "value_template": "{{ value_json.rssi | default(none) }}",
                      "unit_of_measurement": "dBFS", "state_class": "measurement",
                      "entity_category": "diagnostic", "icon": "mdi:signal",
                  }),
                  ("sensor", "snr", "SNR", {
                      "value_template": "{{ value_json.snr | default(none) }}",
                      "unit_of_measurement": "dB", "state_class": "measurement",
                      "entity_category": "diagnostic", "icon": "mdi:signal-variant",
                  }),
                  ("sensor", "noise", "Noise Floor", {
                      "value_template": "{{ value_json.noise | default(none) }}",
                      "unit_of_measurement": "dBFS", "state_class": "measurement",
                      "entity_category": "diagnostic", "icon": "mdi:waveform",
                  }),
                  ("sensor", "freq1", "FSK High Frequency", {
                      "value_template": "{{ value_json.freq1 | default(none) }}",
                      "unit_of_measurement": "MHz", "state_class": "measurement",
                      "entity_category": "diagnostic", "icon": "mdi:sine-wave",
                  }),
                  ("sensor", "freq2", "FSK Low Frequency", {
                      "value_template": "{{ value_json.freq2 | default(none) }}",
                      "unit_of_measurement": "MHz", "state_class": "measurement",
                      "entity_category": "diagnostic", "icon": "mdi:sine-wave",
                  }),
                  ("sensor", "fsk_deviation_khz", "FSK Deviation", {
                      "value_template": "{{ value_json.fsk_deviation_khz | default(none) }}",
                      "unit_of_measurement": "kHz", "state_class": "measurement",
                      "entity_category": "diagnostic", "icon": "mdi:waveform",
                  }),
                  ("sensor", "reception_rate", "Reception Rate", {
                      "value_template": "{{ value_json.reception_rate | default(none) }}",
                      "unit_of_measurement": "%", "state_class": "measurement",
                      "entity_category": "diagnostic", "icon": "mdi:percent",
                  }),
                  ("sensor", "packets_missed_est", "Estimated Missed Packets", {
                      "value_template": "{{ value_json.packets_missed_est | default(none) }}",
                      "entity_category": "diagnostic", "icon": "mdi:counter",
                  }),
              )
              for component, entity, name, extra in entities:
                  config = dict(common)
                  config.update({"name": name, "unique_id": f"{device_key}_{entity}"})
                  config.update(extra)
                  topic = f"homeassistant/{component}/{device_key}_{entity}/config"
                  self._publish(topic, json.dumps(config), retain=True)

          def on_message(self, client, userdata, msg):
              # Reset retained RF status from a previous process incarnation.
              if not msg.retain:
                  return
              prefix = f"{self.prefix}/receivers/{self.receiver_id}/sensors/"
              suffix = "/rf_availability"
              if not msg.topic.startswith(prefix) or not msg.topic.endswith(suffix):
                  return
              key = msg.topic[len(prefix):-len(suffix)]
              if not key.isdecimal():
                  return
              sensor_id = int(key)
              if sensor_id > 65535:
                  return
              with self.lock:
                  if sensor_id in self.sensors or not self.connected:
                      return
                  self.sensors[sensor_id] = {
                      "last_valid": float("-inf"), "interval": 6,
                      "rf_online": False, "last_packet": None,
                      "count": 0, "recovered": True,
                  }
                  self._publish(self._rf_topic(sensor_id), "offline", retain=True)
              print(f"RF sensor {sensor_id} awaiting first valid packet", flush=True)

          def on_connect(self, client, userdata, flags, reason_code, properties):
              if reason_code.is_failure:
                  with self.lock:
                      self.connected = False
                  print(f"MQTT connection rejected: {reason_code}", flush=True)
                  return
              now = time.monotonic()
              with self.lock:
                  self.connected = True
                  snapshots = [
                      (sid, now - state["last_valid"] <
                       self.rf_timeout, state["last_packet"])
                      for sid, state in self.sensors.items()
                  ]
                  for sid, valid, _ in snapshots:
                      self.sensors[sid]["rf_online"] = valid
              subscription = f"{self.prefix}/receivers/{self.receiver_id}/sensors/+/rf_availability"
              result, _ = client.subscribe(subscription, qos=1)
              if result != mqtt.MQTT_ERR_SUCCESS:
                  print(f"RF availability subscription failed: {result}", flush=True)
              print("MQTT connected", flush=True)
              for sensor_id, valid, packet in snapshots:
                  self._discovery(sensor_id)
                  self._publish(self._rf_topic(sensor_id),
                                "online" if valid else "offline", retain=True)
                  if packet is not None:
                      self._publish(self._state_topic(sensor_id), json.dumps(packet), retain=False)
              self._publish(self.receiver_topic, "online", retain=True)
              print(f"Discovery refreshed for {len(snapshots)} sensor(s)", flush=True)

          def on_disconnect(self, client, userdata, flags, reason_code, properties):
              with self.lock:
                  self.connected = False
              if not self.stopping.is_set():
                  print(f"MQTT disconnected: {reason_code} "
                        f"(code={getattr(reason_code, 'value', '?')})", flush=True)

          def on_connect_fail(self, client, userdata):
              if not self.stopping.is_set():
                  print("MQTT transport connect failed; retrying", flush=True)

          def handle_packet(self, msg):
              data = pmt.to_python(msg)
              if not isinstance(data, dict) or not data.get("checksum_ok"):
                  return
              try:
                  sensor_id = int(data["id"])
                  interval = int(data.get("interval", 6))
                  if not 0 <= sensor_id <= 65535 or interval not in (6, 12, 18):
                      return
                  data["received_at"] = datetime.fromtimestamp(
                      float(data["timestamp"]), tz=timezone.utc).isoformat()
                  data["current"] = round(float(data["current"]), 3)
              except (KeyError, TypeError, ValueError, OverflowError) as exc:
                  print(f"Malformed decoded packet: {exc}", flush=True)
                  return

              now = time.monotonic()
              with self.lock:
                  first_seen = sensor_id not in self.sensors or self.sensors[sensor_id].get("recovered", False)
                  if first_seen:
                      self.sensors[sensor_id] = {
                          "last_valid": now, "interval": interval,
                          "rf_online": True, "last_packet": data, "count": 0,
                      }
                      was_offline = True
                  else:
                      sensor = self.sensors[sensor_id]
                      was_offline = not sensor["rf_online"]
                      sensor.update(last_valid=now, interval=interval,
                                    rf_online=True, last_packet=data, recovered=False)
                  self.sensors[sensor_id]["count"] += 1
                  data["sensor_packet_count"] = self.sensors[sensor_id]["count"]
                  self.sensors[sensor_id]["last_packet"] = data
                  connected = self.connected

              if not connected:
                  print(f"RF valid id={sensor_id}, MQTT disconnected", flush=True)
                  return
              if first_seen:
                  self._discovery(sensor_id)
                  print(f"Discovered Efergy sensor {sensor_id}", flush=True)
              if was_offline:
                  self._publish(self._rf_topic(sensor_id), "online", retain=True)
                  print(f"RF sensor {sensor_id} online ({interval}s interval)", flush=True)
              self._publish(self._state_topic(sensor_id), json.dumps(data))
              # Optional shared event stream remains compatible with existing subscriptions.
              self._publish(self.mqtt_topic, json.dumps(data))

          def _watchdog_loop(self):
              while not self.stopping.wait(1.0):
                  now = time.monotonic()
                  expired = []
                  with self.lock:
                      for sensor_id, sensor in self.sensors.items():
                          timeout = self.rf_timeout
                          if sensor["rf_online"] and now - sensor["last_valid"] >= timeout:
                              sensor["rf_online"] = False
                              expired.append((sensor_id, timeout))
                      connected = self.connected
                  for sensor_id, timeout in expired:
                      if connected:
                          self._publish(self._rf_topic(sensor_id), "offline", retain=True)
                      print(f"RF sensor {sensor_id} offline after {timeout:g}s", flush=True)

          def stop(self):
              self.stopping.set()
              self.watchdog.join(timeout=2)
              if self.client.is_connected():
                  with self.lock:
                      ids = list(self.sensors)
                  topics = [self.receiver_topic] + [self._rf_topic(sid) for sid in ids]
                  for topic in topics:
                      try:
                          result = self.client.publish(topic, "offline", qos=1, retain=True)
                          if result.rc == mqtt.MQTT_ERR_SUCCESS:
                              result.wait_for_publish(timeout=2)
                      except (RuntimeError, ValueError):
                          pass
              self.client.disconnect()
              self.client.loop_stop()
              return True
    mqtt_host: os.environ.get("ENGAGE_MQTT_HOST", "homeassistant.local")
    mqtt_password: os.environ.get("ENGAGE_MQTT_PASSWORD", "")
    mqtt_port: '1883'
    mqtt_topic: '"efergy/events"'
    mqtt_user: os.environ.get("ENGAGE_MQTT_USER", "")
    receiver_id: os.environ.get("ENGAGE_RECEIVER_ID", os.uname().nodename)
    sensor_topic_prefix: '"engage"'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '2'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 150e3, 40e3)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 20e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/2
    type: fir_filter_fff
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: RX1
    args: os.environ.get("ENGAGE_SDR_ARGS", "bladerf=0")
    bb_gain0: '20'
    bw0: samp_rate
    freq0: freq
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    name: '"RF Spectrum"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Engage Signal Power"'
    size: '16384'
    srate: samp_rate / 2
    tr_delay: '0.005'
    tr_level: '0.001'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '.01'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"FSK Demodulated"'
    nconnections: '2'
    size: '16384'
    srate: samp_rate / 2
    tr_chan: '1'
    tr_delay: '0.005'
    tr_level: '0.001'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"Digital Pulses"'
    nconnections: '2'
    size: '16384'
    srate: samp_rate / 2
    tr_chan: '1'
    tr_delay: '0.005'
    tr_level: '0.001'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '1.2'
    ymin: '-0.2'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    int_max: '-55'
    int_min: '-100'
    name: '"RF Waterfall"'
    type: complex
    update_time: '0.005'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / 2
    fc: freq
    fftsize: '512'
    grid: 'True'
    int_max: '-35'
    int_min: '-75'
    name: '"Filtered Engage Signal"'
    type: complex
    update_time: '0.01'
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', epy_block_0, '1']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_2, '1']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', epy_block_0, '0']
- [epy_block_0, packet, blocks_message_debug_0, print]
- [epy_block_0, packet, epy_block_1, packet]
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_1, '0']
- [low_pass_filter_0, '0', digital_binary_slicer_fb_0, '0']
- [low_pass_filter_0, '0', epy_block_0, '2']
- [low_pass_filter_0, '0', qtgui_time_sink_x_1, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
